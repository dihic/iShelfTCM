# Keil uVision project iStorageTCMUnit.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC11C24/301 NXP
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: iStorageTCMUnit +hex
  c flags: Optim=1 oTime=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Source Group 1
    ./: startup_LPC11xx.s canonchip.c gpio.c iso15693.c ssp.c system_LPC11xx.c timer32.c trf796x.c uart.c display.cpp fram.cpp hx711.cpp main.cpp SensorArray.cpp CardInfo.cpp delay.c
