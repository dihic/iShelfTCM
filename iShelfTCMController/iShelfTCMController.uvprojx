# Keil uVision project iShelfTCMController.uvprojx, settings and files
target Debug (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: iShelfTCMController +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: HSE_VALUE=25000000, DEBUG_PRINT
  c misc: --gnu
  c include: .\bson;.\
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./: CanDevice.cpp CommStructures.cpp ConfigComm.cpp main.cpp NetworkConfig.cpp NetworkEngine.cpp Retarget.cpp TcpClient.cpp UnitManager.cpp System.c StorageUnit.cpp
  group Driver
    ./: CanEx.cpp CAN_STM32F40x.c Driver_CAN.c FRAM.cpp
  group Bson
    ./: TypeInfoBase.cpp
    ./bson/: BsonBinary.cpp BsonCString.cpp BsonDocument.cpp BsonString.cpp Element.cpp Guid.cpp MemStream.cpp
target Release (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: as above
  output: iShelfTCMController +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: HSE_VALUE=25000000
  c misc: --gnu
  c include: .\bson;.\
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, Network:CORE 6.3.0, Network:Interface:ETH 6.3.0, Network:Socket:TCP 6.3.0, Network:Socket:UDP 6.3.0, CMSIS Driver:Ethernet:KSZ8851SNL 6.02, CMSIS Driver:SPI 2.02, CMSIS Driver:USART 2.01, Device:STM32Cube Framework:Classic 1.1.0, Device:STM32Cube HAL:CAN 1.1.0, Device:STM32Cube HAL:Common 1.1.0, Device:STM32Cube HAL:Cortex 1.1.0, Device:STM32Cube HAL:DMA 1.1.0, Device:STM32Cube HAL:GPIO 1.1.0, Device:STM32Cube HAL:PWR 1.1.0, Device:STM32Cube HAL:RCC 1.1.0, Device:STM32Cube HAL:RNG 1.1.0, Device:STM32Cube HAL:SPI 1.1.0, Device:STM32Cube HAL:UART 1.1.0, Device:STM32Cube HAL:USART 1.1.0, Device:Startup 2.1.0
